V1 1 0 DC 5V
R1 1 2 1k
.end
